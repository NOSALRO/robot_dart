Commit message: [ur3e]: remove uneeded frame [ci skip]

File: robots/ur3e/ur3e_with_schunk_hand.urdf (robot description, URDF)
Before this commit: robot ur3e_with_schunk_hand, 43 links, 42 joints
Links:
- removed link table_base_link
Joints:
- removed joint table_base_to_base
