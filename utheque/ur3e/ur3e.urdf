Commit message: [ur3e]: minor fix for URDF

File: utheque/ur3e/ur3e.urdf (robot description, URDF)
Before this commit: robot ur3e_with_schunk_hand, 11 links, 10 joints
Links:
- link base_link: mass None -> 1e-8
